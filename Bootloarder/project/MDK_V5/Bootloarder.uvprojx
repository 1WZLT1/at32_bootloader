# Keil uVision project Bootloarder.uvprojx, settings and files
target Bootloarder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloarder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER,BOARD_ID=HW_ID_IMU_VF435_V1_688_1111,BOOT_BASE=0x08010000,Firmware0_Base=0x08010000
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\IAP;..\system;..\hardware
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_usart.c wk_dma.c wk_tmr.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_dma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_misc.c at32f435_437_ertc.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group IAP
    ../IAP/: IAP.c
  group hardware
    ../hardware/: uart_serve.c
  group system
    ../system/: ring_buffer.c memory_alloc.c SerialBoot.c Decode.c Hardware_Name.c
